## src/drivers/encoder/Kconfig
```kconfig
menuconfig DRIVERS_ENCODER
	bool "encoder"
	default n
	---help---
		Enable motor encoder driver
```
